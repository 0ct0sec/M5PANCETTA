/**
 * pixel_primitives.cpp — fat-pixel drawing primitives implementation
 */
#include "pixel_primitives.h"
#include "gfx/gfx.h"

namespace PixelPrim {

// ==[ FAT LINE 4PX ]== Bresenham with 4px cell coverage
void fatLine4(M5Canvas& c, int x0, int y0, int x1, int y1, uint16_t col) {
    x0 = q4(x0); y0 = q4(y0); x1 = q4(x1); y1 = q4(y1);
    int dx = abs(x1 - x0), sx = x0 < x1 ? 4 : -4;
    int dy = -abs(y1 - y0), sy = y0 < y1 ? 4 : -4;
    int err = dx + dy, e2;

    while (true) {
        // Gfx::fastFillBlock4 is unchecked (perf) and needs an in-bounds,
        // 4-aligned block. Clip here so an off-canvas endpoint cannot write
        // outside the canvas buffer.
        if (x0 >= 0 && x0 <= c.width() - 4 && y0 >= 0 && y0 <= c.height() - 4)
            Gfx::fastFillBlock4(c, x0, y0, col);
        if (x0 == x1 && y0 == y1) break;
        e2 = 2 * err;
        if (e2 >= dy) { err += dy; x0 += sx; }
        if (e2 <= dx) { err += dx; y0 += sy; }
    }
}

// ==[ FAT LINE 2PX ]==
void fatLine2(M5Canvas& c, int x0, int y0, int x1, int y1, uint16_t col) {
    x0 = q2(x0); y0 = q2(y0); x1 = q2(x1); y1 = q2(y1);
    int dx = abs(x1 - x0), sx = x0 < x1 ? 2 : -2;
    int dy = -abs(y1 - y0), sy = y0 < y1 ? 2 : -2;
    int err = dx + dy, e2;

    while (true) {
        Gfx::fastFillBlock2(c, x0, y0, col);
        if (x0 == x1 && y0 == y1) break;
        e2 = 2 * err;
        if (e2 >= dy) { err += dy; x0 += sx; }
        if (e2 <= dx) { err += dx; y0 += sy; }
    }
}

// ==[ CIRCLE 4PX ]== Midpoint circle, draws 4px blocks at octants
void circle4(M5Canvas& c, int cx, int cy, int r, uint16_t col) {
    cx = q4(cx); cy = q4(cy); r = q4(r);
    int x = 0, y = r;
    int d = 3 - 2 * r;
    auto drawOctants = [&](int x, int y) {
        Gfx::fastFillBlock4(c, cx + x, cy + y, col);
        Gfx::fastFillBlock4(c, cx - x, cy + y, col);
        Gfx::fastFillBlock4(c, cx + x, cy - y, col);
        Gfx::fastFillBlock4(c, cx - x, cy - y, col);
        Gfx::fastFillBlock4(c, cx + y, cy + x, col);
        Gfx::fastFillBlock4(c, cx - y, cy + x, col);
        Gfx::fastFillBlock4(c, cx + y, cy - x, col);
        Gfx::fastFillBlock4(c, cx - y, cy - x, col);
    };
    drawOctants(x, y);
    while (y >= x) {
        x += 4;
        if (d > 0) { y -= 4; d = d + 4 * (x - y) + 10; }
        else { d = d + 4 * x + 6; }
        drawOctants(x, y);
    }
}

// ==[ ELLIPSE 4PX ]== Midpoint ellipse
void ellipse4(M5Canvas& c, int cx, int cy, int rx, int ry, uint16_t col) {
    cx = q4(cx); cy = q4(cy); rx = q4(rx); ry = q4(ry);
    int x = 0, y = ry;
    int rx2 = rx * rx, ry2 = ry * ry;
    int twoRx2 = 2 * rx2, twoRy2 = 2 * ry2;
    int px = 0, py = twoRx2 * y;

    auto plot = [&](int x, int y) {
        Gfx::fastFillBlock4(c, cx + x, cy + y, col);
        Gfx::fastFillBlock4(c, cx - x, cy + y, col);
        Gfx::fastFillBlock4(c, cx + x, cy - y, col);
        Gfx::fastFillBlock4(c, cx - x, cy - y, col);
    };

    // Region 1
    int d = ry2 - rx2 * ry + rx2 / 4;
    while (px < py) {
        plot(x, y);
        x += 4; px += twoRy2;
        if (d < 0) d += ry2 + px;
        else { y -= 4; py -= twoRx2; d += ry2 + px - py; }
    }
    // Region 2
    d = (int)(ry2 * (x + 2) * (x + 2) + rx2 * (y - 2) * (y - 2) - rx2 * ry2);
    while (y >= 0) {
        plot(x, y);
        y -= 4; py -= twoRx2;
        if (d > 0) d += rx2 - py;
        else { x += 4; px += twoRy2; d += rx2 - py + px; }
    }
}

// ==[ ROUNDED RECT 4PX ]== 4px corner radius
void roundRect4(M5Canvas& c, int x, int y, int w, int h, uint16_t col) {
    x = q4(x); y = q4(y); w = q4(w); h = q4(h);
    if (w < 8 || h < 8) { fillRect4(c, x, y, w, h, col); return; }
    int r = 4;
    // Top/bottom edges (excluding corners)
    fillRect4(c, x + r, y, w - 2 * r, r, col);
    fillRect4(c, x + r, y + h - r, w - 2 * r, r, col);
    // Middle
    fillRect4(c, x, y + r, w, h - 2 * r, col);
    // Corners (4 quadrants of 4px circle)
    for (int dy = 0; dy < r; dy += 4) {
        int dx = (int)sqrtf(r * r - dy * dy);
        dx = q4(dx);
        // TL
        fillRect4(c, x + r - dx, y + dy, dx, 4, col);
        // TR
        fillRect4(c, x + w - r, y + dy, dx, 4, col);
        // BL
        fillRect4(c, x + r - dx, y + h - r - dy, dx, 4, col);
        // BR
        fillRect4(c, x + w - r, y + h - r - dy, dx, 4, col);
    }
}

// ==[ TRIANGLES ]== Flat bottom/top, grid-snapped
void triangleFlatBottom4(M5Canvas& c, int x1, int y1, int x2, int y2, int x3, int y3, uint16_t col) {
    // y1==y2 (top edge), y3 > y1 (bottom vertex)
    x1 = q4(x1); y1 = q4(y1); x2 = q4(x2); y2 = q4(y2); x3 = q4(x3); y3 = q4(y3);
    float invSlope1 = (float)(x3 - x1) / (y3 - y1);
    float invSlope2 = (float)(x3 - x2) / (y3 - y2);
    float curX1 = x1, curX2 = x2;
    for (int y = y1; y <= y3; y += 4) {
        int xl = q4((int)curX1);
        int xr = q4((int)curX2);
        fillRect4(c, xl, y, xr - xl + 4, 4, col);
        curX1 += invSlope1 * 4;
        curX2 += invSlope2 * 4;
    }
}
void triangleFlatTop4(M5Canvas& c, int x1, int y1, int x2, int y2, int x3, int y3, uint16_t col) {
    // y2==y3 (bottom edge), y1 < y2 (top vertex)
    x1 = q4(x1); y1 = q4(y1); x2 = q4(x2); y2 = q4(y2); x3 = q4(x3); y3 = q4(y3);
    float invSlope1 = (float)(x2 - x1) / (y2 - y1);
    float invSlope2 = (float)(x3 - x1) / (y3 - y1);
    float curX1 = x1, curX2 = x1;
    for (int y = y1; y <= y2; y += 4) {
        int xl = q4((int)curX1);
        int xr = q4((int)curX2);
        fillRect4(c, xl, y, xr - xl + 4, 4, col);
        curX1 += invSlope1 * 4;
        curX2 += invSlope2 * 4;
    }
}

// ==[ BLOCK GLYPH 5×7 ]== Authored 5×7 font, multi-layer
static const uint8_t kFont5x7[96][7] = {
    // ' ' (32)
    {0x00,0x00,0x00,0x00,0x00,0x00,0x00},
    // '!' (33)
    {0x04,0x04,0x04,0x04,0x04,0x00,0x04},
    // '"' (34)
    {0x0A,0x0A,0x0A,0x00,0x00,0x00,0x00},
    // '#' (35)
    {0x0A,0x0A,0x1F,0x0A,0x1F,0x0A,0x0A},
    // '$' (36)
    {0x04,0x0F,0x14,0x0E,0x05,0x1E,0x04},
    // '%' (37)
    {0x18,0x19,0x02,0x04,0x08,0x13,0x03},
    // '&' (38)
    {0x0C,0x12,0x14,0x08,0x14,0x12,0x0D},
    // ''' (39)
    {0x04,0x04,0x04,0x00,0x00,0x00,0x00},
    // '(' (40)
    {0x02,0x04,0x08,0x08,0x08,0x04,0x02},
    // ')' (41)
    {0x08,0x04,0x02,0x02,0x02,0x04,0x08},
    // '*' (42)
    {0x00,0x04,0x15,0x0E,0x15,0x04,0x00},
    // '+' (43)
    {0x00,0x04,0x04,0x1F,0x04,0x04,0x00},
    // ',' (44)
    {0x00,0x00,0x00,0x00,0x04,0x04,0x08},
    // '-' (45)
    {0x00,0x00,0x00,0x1F,0x00,0x00,0x00},
    // '.' (46)
    {0x00,0x00,0x00,0x00,0x00,0x04,0x04},
    // '/' (47)
    {0x01,0x02,0x04,0x08,0x10,0x00,0x00},
    // '0' (48)
    {0x0E,0x11,0x13,0x15,0x19,0x11,0x0E},
    // '1' (49)
    {0x04,0x0C,0x04,0x04,0x04,0x04,0x0E},
    // '2' (50)
    {0x0E,0x11,0x01,0x02,0x04,0x08,0x1F},
    // '3' (51)
    {0x1F,0x02,0x04,0x02,0x01,0x11,0x0E},
    // '4' (52)
    {0x02,0x06,0x0A,0x12,0x1F,0x02,0x02},
    // '5' (53)
    {0x1F,0x10,0x1E,0x01,0x01,0x11,0x0E},
    // '6' (54)
    {0x06,0x08,0x10,0x1E,0x11,0x11,0x0E},
    // '7' (55)
    {0x1F,0x01,0x02,0x04,0x08,0x08,0x08},
    // '8' (56)
    {0x0E,0x11,0x11,0x0E,0x11,0x11,0x0E},
    // '9' (57)
    {0x0E,0x11,0x11,0x0F,0x01,0x02,0x0C},
    // ':' (58)
    {0x00,0x04,0x04,0x00,0x04,0x04,0x00},
    // ';' (59)
    {0x00,0x04,0x04,0x00,0x04,0x04,0x08},
    // '<' (60)
    {0x02,0x04,0x08,0x10,0x08,0x04,0x02},
    // '=' (61)
    {0x00,0x00,0x1F,0x00,0x1F,0x00,0x00},
    // '>' (62)
    {0x08,0x04,0x02,0x01,0x02,0x04,0x08},
    // '?' (63)
    {0x0E,0x11,0x01,0x02,0x04,0x00,0x04},
    // '@' (64)
    {0x0E,0x11,0x01,0x0D,0x15,0x15,0x0E},
    // 'A' (65)
    {0x0E,0x11,0x11,0x1F,0x11,0x11,0x11},
    // 'B' (66)
    {0x1E,0x11,0x11,0x1E,0x11,0x11,0x1E},
    // 'C' (67)
    {0x0E,0x11,0x10,0x10,0x10,0x11,0x0E},
    // 'D' (68)
    {0x1C,0x12,0x11,0x11,0x11,0x12,0x1C},
    // 'E' (69)
    {0x1F,0x10,0x10,0x1E,0x10,0x10,0x1F},
    // 'F' (70)
    {0x1F,0x10,0x10,0x1E,0x10,0x10,0x10},
    // 'G' (71)
    {0x0E,0x11,0x10,0x17,0x11,0x11,0x0E},
    // 'H' (72)
    {0x11,0x11,0x11,0x1F,0x11,0x11,0x11},
    // 'I' (73)
    {0x1F,0x04,0x04,0x04,0x04,0x04,0x1F},
    // 'J' (74)
    {0x1F,0x02,0x02,0x02,0x02,0x12,0x0C},
    // 'K' (75)
    {0x11,0x12,0x14,0x18,0x14,0x12,0x11},
    // 'L' (76)
    {0x10,0x10,0x10,0x10,0x10,0x10,0x1F},
    // 'M' (77)
    {0x11,0x1B,0x15,0x15,0x11,0x11,0x11},
    // 'N' (78)
    {0x11,0x19,0x15,0x13,0x11,0x11,0x11},
    // 'O' (79)
    {0x0E,0x11,0x11,0x11,0x11,0x11,0x0E},
    // 'P' (80)
    {0x1E,0x11,0x11,0x1E,0x10,0x10,0x10},
    // 'Q' (81)
    {0x0E,0x11,0x11,0x11,0x15,0x12,0x0D},
    // 'R' (82)
    {0x1E,0x11,0x11,0x1E,0x14,0x12,0x11},
    // 'S' (83)
    {0x0E,0x11,0x10,0x0E,0x01,0x11,0x0E},
    // 'T' (84)
    {0x1F,0x04,0x04,0x04,0x04,0x04,0x04},
    // 'U' (85)
    {0x11,0x11,0x11,0x11,0x11,0x11,0x0E},
    // 'V' (86)
    {0x11,0x11,0x11,0x11,0x11,0x0A,0x04},
    // 'W' (87)
    {0x11,0x11,0x11,0x15,0x15,0x1B,0x11},
    // 'X' (88)
    {0x11,0x11,0x0A,0x04,0x0A,0x11,0x11},
    // 'Y' (89)
    {0x11,0x11,0x0A,0x04,0x04,0x04,0x04},
    // 'Z' (90)
    {0x1F,0x01,0x02,0x04,0x08,0x10,0x1F},
    // '[' (91)
    {0x0E,0x08,0x08,0x08,0x08,0x08,0x0E},
    // '\' (92)
    {0x10,0x10,0x08,0x04,0x02,0x01,0x01},
    // ']' (93)
    {0x0E,0x02,0x02,0x02,0x02,0x02,0x0E},
    // '^' (94)
    {0x04,0x0A,0x11,0x00,0x00,0x00,0x00},
    // '_' (95)
    {0x00,0x00,0x00,0x00,0x00,0x00,0x1F},
    // '`' (96)
    {0x08,0x04,0x02,0x00,0x00,0x00,0x00},
    // 'a' (97)
    {0x00,0x00,0x0E,0x01,0x0F,0x11,0x0F},
    // 'b' (98)
    {0x10,0x10,0x1E,0x11,0x11,0x11,0x1E},
    // 'c' (99)
    {0x00,0x00,0x0E,0x10,0x10,0x11,0x0E},
    // 'd' (100)
    {0x01,0x01,0x0D,0x13,0x11,0x11,0x0F},
    // 'e' (101)
    {0x00,0x00,0x0E,0x11,0x1F,0x10,0x0E},
    // 'f' (102)
    {0x06,0x08,0x08,0x1C,0x08,0x08,0x08},
    // 'g' (103)
    {0x00,0x0E,0x11,0x11,0x0F,0x01,0x0E},
    // 'h' (104)
    {0x10,0x10,0x1E,0x11,0x11,0x11,0x11},
    // 'i' (105)
    {0x04,0x00,0x0C,0x04,0x04,0x04,0x0E},
    // 'j' (106)
    {0x02,0x00,0x06,0x02,0x02,0x12,0x0C},
    // 'k' (107)
    {0x10,0x10,0x12,0x14,0x18,0x14,0x13},
    // 'l' (108)
    {0x0C,0x04,0x04,0x04,0x04,0x04,0x0E},
    // 'm' (109)
    {0x00,0x00,0x1A,0x15,0x11,0x11,0x11},
    // 'n' (110)
    {0x00,0x00,0x1E,0x11,0x11,0x11,0x11},
    // 'o' (111)
    {0x00,0x00,0x0E,0x11,0x11,0x11,0x0E},
    // 'p' (112)
    {0x00,0x00,0x1E,0x11,0x11,0x1E,0x10},
    // 'q' (113)
    {0x00,0x00,0x0F,0x11,0x11,0x0F,0x01},
    // 'r' (114)
    {0x00,0x00,0x1E,0x11,0x10,0x10,0x10},
    // 's' (115)
    {0x00,0x00,0x0E,0x10,0x0E,0x01,0x1E},
    // 't' (116)
    {0x08,0x08,0x1C,0x08,0x08,0x09,0x06},
    // 'u' (117)
    {0x00,0x00,0x11,0x11,0x11,0x11,0x0F},
    // 'v' (118)
    {0x00,0x00,0x11,0x11,0x11,0x0A,0x04},
    // 'w' (119)
    {0x00,0x00,0x11,0x11,0x15,0x15,0x0A},
    // 'x' (120)
    {0x00,0x00,0x11,0x0A,0x04,0x0A,0x11},
    // 'y' (121)
    {0x00,0x00,0x11,0x11,0x0F,0x01,0x0E},
    // 'z' (122)
    {0x00,0x00,0x1F,0x02,0x04,0x08,0x1F},
    // '{' (123)
    {0x02,0x04,0x04,0x08,0x04,0x04,0x02},
    // '|' (124)
    {0x04,0x04,0x04,0x04,0x04,0x04,0x04},
    // '}' (125)
    {0x08,0x04,0x04,0x02,0x04,0x04,0x08},
    // '~' (126)
    {0x00,0x00,0x00,0x0A,0x04,0x11,0x00},
    // DEL (127)
    {0x00,0x00,0x00,0x00,0x00,0x00,0x00},
};

void drawBlockGlyph5x7(M5Canvas& c, int cx, int cy, char ch, int cell,
                       const GlyphLayer* layers, int nLayers) {
    if (ch < 32 || ch > 127) ch = '?';
    const uint8_t* glyph = kFont5x7[ch - 32];
    int x0 = cx - (5 * cell) / 2;
    int y0 = cy - (7 * cell) / 2;
    x0 = q4(x0); y0 = q4(y0);
    for (int row = 0; row < 7; row++) {
        uint8_t bits = glyph[row];
        for (int col = 0; col < 5; col++) {
            if ((bits & (0x10 >> col)) == 0) continue;
            int px = x0 + col * cell;
            int py = y0 + row * cell;
            for (int l = 0; l < nLayers; l++) {
                int lx = px + layers[l].dx * cell;
                int ly = py + layers[l].dy * cell;
                if (cell == 4) Gfx::fastFillBlock4(c, lx, ly, layers[l].color);
                else Gfx::fastFillBlock2(c, lx, ly, layers[l].color);
            }
        }
    }
}

void drawBlockText5x7(M5Canvas& c, int cx, int cy, const char* text, int cell,
                      const GlyphLayer* layers, int nLayers, int spacing) {
    int len = strlen(text);
    int totalW = len * 5 * cell + (len - 1) * spacing;
    int x = cx - totalW / 2;
    x = q4(x);
    for (int i = 0; i < len; i++) {
        drawBlockGlyph5x7(c, x + (5 * cell) / 2 + i * (5 * cell + spacing), cy,
                          text[i], cell, layers, nLayers);
    }
}

} // namespace PixelPrim
