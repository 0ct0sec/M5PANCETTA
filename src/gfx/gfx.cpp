// gfx.cpp — LUT data + non-inline rendering primitives
#include "gfx.h"

namespace Gfx {

// ==[ COLOR OPS ]==

// HSV to RGB565. h: 0-359, s: 0-255, v: 0-255
uint16_t hsvToRgb565(uint16_t h, uint8_t s, uint8_t v) {
    if (s == 0) {
        uint8_t v5 = v >> 3;
        uint8_t v6 = v >> 2;
        return (v5 << 11) | (v6 << 5) | v5;
    }
    h = h % 360;
    uint8_t region = h / 60;
    uint16_t frac = h - (uint16_t)(region * 60);       // 0-59
    uint16_t remainder = (uint16_t)((frac * 255) / 59); // 0-255 proper
    if (remainder > 255) remainder = 255;               // clamp edge

    // intermediate products use uint16_t — max 255*255 = 65025, fits
    uint8_t p = (uint8_t)(((uint16_t)v * (255 - s)) >> 8);
    uint8_t q = (uint8_t)(((uint16_t)v * (255 - (((uint16_t)s * remainder) >> 8))) >> 8);
    uint8_t t = (uint8_t)(((uint16_t)v * (255 - (((uint16_t)s * (255 - remainder)) >> 8))) >> 8);

    uint8_t r8, g8, b8;
    switch (region) {
        case 0:  r8 = v; g8 = t; b8 = p; break;
        case 1:  r8 = q; g8 = v; b8 = p; break;
        case 2:  r8 = p; g8 = v; b8 = t; break;
        case 3:  r8 = p; g8 = q; b8 = v; break;
        case 4:  r8 = t; g8 = p; b8 = v; break;
        default: r8 = v; g8 = p; b8 = q; break;
    }
    return ((r8 >> 3) << 11) | ((g8 >> 2) << 5) | (b8 >> 3);
}

// RGB565 perceived brightness (0-255 range)
uint8_t brightness565(uint16_t c) {
    uint8_t r = (c >> 11) & 0x1F;
    uint8_t g = (c >> 5) & 0x3F;
    uint8_t b = c & 0x1F;
    // Expand to 8-bit and average: (R8 + G8 + B8) / 3
    // Max: (248 + 252 + 248) / 3 = 249 — fits uint8_t
    return (uint8_t)((r * 8u + g * 4u + b * 8u) / 3u);
}

uint16_t lerpColor565(uint16_t c1, uint16_t c2, float t) {
    if (t <= 0.0f) return c1;
    if (t >= 1.0f) return c2;
    // fixed-point Q8: 0-256 range avoids per-channel float multiply
    uint16_t t8 = (uint16_t)(t * 256.0f);
    int r1 = (c1 >> 11) & 0x1F, g1 = (c1 >> 5) & 0x3F, b1 = c1 & 0x1F;
    int r2 = (c2 >> 11) & 0x1F, g2 = (c2 >> 5) & 0x3F, b2 = c2 & 0x1F;
    uint8_t r = r1 + (((r2 - r1) * t8) >> 8);
    uint8_t g = g1 + (((g2 - g1) * t8) >> 8);
    uint8_t b = b1 + (((b2 - b1) * t8) >> 8);
    return (r << 11) | (g << 5) | b;
}

// ==[ SINE LUT ]== 256-entry Q15 — fastSinf() wrapper in header
const int16_t SIN_LUT_Q15[256] = {
        0,    804,   1608,   2410,   3212,   4011,   4808,   5602,
     6393,   7179,   7962,   8739,   9512,  10278,  11039,  11793,
    12539,  13279,  14010,  14732,  15446,  16151,  16846,  17530,
    18204,  18868,  19519,  20159,  20787,  21403,  22005,  22594,
    23170,  23731,  24279,  24811,  25329,  25832,  26319,  26790,
    27245,  27683,  28105,  28510,  28898,  29268,  29621,  29956,
    30273,  30571,  30852,  31113,  31356,  31580,  31785,  31971,
    32137,  32285,  32412,  32521,  32609,  32678,  32728,  32757,
    32767,  32757,  32728,  32678,  32609,  32521,  32412,  32285,
    32137,  31971,  31785,  31580,  31356,  31113,  30852,  30571,
    30273,  29956,  29621,  29268,  28898,  28510,  28105,  27683,
    27245,  26790,  26319,  25832,  25329,  24811,  24279,  23731,
    23170,  22594,  22005,  21403,  20787,  20159,  19519,  18868,
    18204,  17530,  16846,  16151,  15446,  14732,  14010,  13279,
    12539,  11793,  11039,  10278,   9512,   8739,   7962,   7179,
     6393,   5602,   4808,   4011,   3212,   2410,   1608,    804,
        0,   -804,  -1608,  -2410,  -3212,  -4011,  -4808,  -5602,
    -6393,  -7179,  -7962,  -8739,  -9512, -10278, -11039, -11793,
   -12539, -13279, -14010, -14732, -15446, -16151, -16846, -17530,
   -18204, -18868, -19519, -20159, -20787, -21403, -22005, -22594,
   -23170, -23731, -24279, -24811, -25329, -25832, -26319, -26790,
   -27245, -27683, -28105, -28510, -28898, -29268, -29621, -29956,
   -30273, -30571, -30852, -31113, -31356, -31580, -31785, -31971,
   -32137, -32285, -32412, -32521, -32609, -32678, -32728, -32757,
   -32767, -32757, -32728, -32678, -32609, -32521, -32412, -32285,
   -32137, -31971, -31785, -31580, -31356, -31113, -30852, -30571,
   -30273, -29956, -29621, -29268, -28898, -28510, -28105, -27683,
   -27245, -26790, -26319, -25832, -25329, -24811, -24279, -23731,
   -23170, -22594, -22005, -21403, -20787, -20159, -19519, -18868,
   -18204, -17530, -16846, -16151, -15446, -14732, -14010, -13279,
   -12539, -11793, -11039, -10278,  -9512,  -8739,  -7962,  -7179,
    -6393,  -5602,  -4808,  -4011,  -3212,  -2410,  -1608,   -804,
};

// ==[ DITHERING ]==
// Bayer 4x4 ordered dithering matrix (0-255 thresholds)
const uint8_t bayer4[4][4] = {
    {  0, 128,  32, 160},
    {192,  64, 224,  96},
    { 48, 176,  16, 144},
    {240, 112, 208,  80}
};

} // namespace Gfx
